*
simulator lang=spectre
include "./spectre/gpdk045.scs" section=mc
include "./spectre/gpdk045_mos.scs" section=res_rg
simulator lang=spice
